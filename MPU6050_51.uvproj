# Keil uVision project MPU6050_51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: MPU6050_51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library;.\User;..\MPU6050_51
  group Source Group 1
    ./: STARTUP.A51 main.c
  group Library
    ./Library/: mpu6050.c digtube.c
